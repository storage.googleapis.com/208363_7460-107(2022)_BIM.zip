Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-01-19T22:48:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 19 22:48:53 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{4D158AEB-B35E-4461-BD56-AB9567B47F6E}\ifc * Database version: 5507 * Database creation date: Wed Jan 19 22:48:52 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 19 22:48:52 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 19 22:48:52 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7460-107 Shower faucet, 7460-107(2022):7460-107 Shower faucet:484840
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - NominalDepth: 84 mm; NominalHeight: 63.4 mm; NominalWidth: 290 mm
Type - General - Author: Convergo AB; BIMObjectName: 7460-107(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: Thermostatic shower faucet; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/01/2022
Type - Green Building Properties - Approval KIWA SE Type Approval: 1598; EAN Number: 6414150100314; EN Standard: EN 1111; Sales Package dimensions (LxWxH): 294 x 164 x 83; Sales Package gross weight: 1.805 kg; Sales Package package weight: 0.2252 kg; STF Certificate: VTT-RTH-00085-17; URL KIWA SE Type Approval: http://static.oras.com/KIWASETypeApproval/7460-107/original; URL REACH: http://static.oras.com/doc/reach; URL STF: http://static.oras.com/STF/7460-107/original
Type - Identity Data - Catalog Drawing URL: http://static.oras.com/catdrw/7460-107; Description: Thermostatic shower faucet; Dimension Drawing URL: http://static.oras.com/dimdrw/7460-107; FDV Document URL: http://www.oras.com/datasheet/7460-107/en/fdv; Group: Shower faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/7460-107; Item Type: Sales item; Long Marketing: Thermostatic shower faucet. Temperature handle equipped with safety stop at 38°C. Volume handle with EcoFlow control. The faucet includes litter filters and non-return valves.; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Russia;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/7460-107; Model: 7460-107 Shower faucet; Name_en: 7460-107 Shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7460-107; Product Family: Oras Nova Eco; Product Image URL: http://static.oras.com/image/7460-107; Product URL: http://static.oras.com/7460-107; Spare-Part Information URL: http://static.oras.com/sp/7460-107; Technical DataSheet URL: http://www.oras.com/datasheet/7460-107/en; Type Name: 7460-107 Shower faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Backflow Prevention EN1717: EB; Connection: Direct connection; Connection Size: G3/4; Flow Rate At 300kPa With Flow Controller: 0.040965 m3/s; Installation Type: Wall mounted; Installation Width: cc150 mm; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Noise Class: I (ISO 3822) Oras lab.; Shower Parts: Eco flow control; Surface treatment: Chrome; Temperature: Thermostatic safety stop at 38°C;Temperature fixable; Temperature Adjustments: Safety stop against scalding at 38°C;Temperature preset fixable; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: EcoFlow control, temperature control handle; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7460-107(2022); Features: Thermostatic;Green Building; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7460-107; Name: 7460-107 Shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 290x84x63.5 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7460-107; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7460-107 Shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0500743 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00155679 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7460-107(2022): 7460-107 Shower faucet; Family and Type: 7460-107(2022): 7460-107 Shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7460-107(2022): 7460-107 Shower faucet; Type Id: 7460-107(2022): 7460-107 Shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
